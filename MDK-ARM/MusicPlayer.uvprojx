# Keil uVision project MusicPlayer.uvprojx, settings and files
target MusicPlayer (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MusicPlayer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Drivers\freeRTOS\Inc;..\Drivers\BSP\Inc;..\Drivers\system\ucmd;..\Drivers\system\ff16;..\Drivers\system\mmf;..\Drivers\system\MP3;..\Drivers\system\MP3\minimp3-master
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32f4xx_it.c stm32f4xx_hal_msp.c apptask.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group freeRTOS
    ../Drivers/freeRTOS/Src/: list.c port.c queue.c tasks.c timers.c heap_4.c
  group ucmd
    ../Drivers/system/ucmd/: ucmd.c
  group BSP
    ../Drivers/BSP/Src/: i2s_driver.c iic_driver.c sd2_driver.c usart_driver.c wm8978_driver.c
  group ff16
    ../Drivers/system/ff16/: diskio.c ff.c ff_app.c ff_platform.c ffsystem.c ffunicode.c
  group mmf
    ../Drivers/system/mmf/: mmf.c
  group MP3
    ../Drivers/system/MP3/: mp3_driver.c
software components: CMSIS:CORE 6.1.0
